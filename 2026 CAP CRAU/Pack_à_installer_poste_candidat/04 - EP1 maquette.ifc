Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-12-16T10:50:41
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy (197)
In: Default Building Storey
Description: Description of Object
Name
45 x Bordure CS2
10 x GNT 0-20
BBSG
45 x Bordure T2
45 x Bordure P3
RG5 - Cadre tampon fonte 250kN
RG5 - Tampon fonte 250kN
RG4 - Cadre tampon fonte 250kN
RG4 - Tampon fonte 250kN
RG3 - Cadre tampon fonte 250kN
RG3 - Tampon fonte 250kN
RG2 - Cadre tampon fonte 250kN
RG2 - Tampon fonte 250 kN
RG1 - Cadre tampon fonte 250kN
RG1 - Tampon fonte 250 kN
RG5 - Elément Droit 1000-900
RG5 - Elément Droit 1000-300
RG4 - Dalle réductrice
RG4 - Elément Droit 1000-600
RG4 - Elément Droit 1000-450
RG2 - Tête réductrice 800
RG1 - Elément Droit 1000-300
RG1 - Dalle réductrice
RG3 - Dalle réductrice
RG3 - Elément Droit 1000-600
RG5 - Dalle Réductrice
RG2 - Cunette 1000
RG3 - Cunette 1000
RG4 - Cunette 1000
RG5 - Cunette 1000
RG1 - Cunette 1000
6 x GNT 0-80
4 x Gravillon 4-6
4 x PVC CR8 D 400
Réseau Gaz
Réseau AEP
Réseau Electrique
Béton Bordure
Béton bordure
Sable 0-4
5 x Object
