Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-11-19T15:53:55
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy (163)
In: Default Building Storey
Description: Description of Object
Name
2 x Bordure P3
17 x Pavé GRANIT 10x10x6
2 x Pavé GRANIT 10x10x6 coupé
Joint de dilatation
Sable stabilisé
98 x Pavé 10x10x4
4 x Pavé 10x10x4#coupe
Béton balayé
Bordure T1 0,50 m.
5 x Bordure T1 0,50 m
Béton de pose - 250 kg/m3
Béton de pose - 250 kg/m3#1
2 x Planche de coffrage
27 x Object
